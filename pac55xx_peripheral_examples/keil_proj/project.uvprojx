# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PAC55XX Active-Semi
  pack: Active-Semi.PAC55XX.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  BeforeMake: cmd.exe /k "IF EXIST ..\..\build_date_time.bat (..\..\build_date_time.bat .\ keil) ELSE (exit)"
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\code_protection_keil.bin"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c include: .;..;..\src;..\pac55xx_sdk;..\pac55xx_sdk\boot_keil;..\pac55xx_sdk\device; ..\pac55xx_sdk\driver;..\pac55xx_sdk\peripheral;..\src\gpio;..\src\gptimera;..\src\gptimerb;..\src\rtc;..\src\sysclk;..\src\timer;..\src\uart;..\src\wwdt;..\src\adc_aio;..\src\crc;..\src\can;..\src\power;..\src\hibernate;..\src\user;..\src\flash;..\src\i2c;..\src\ssp;..\src\sleep;..\src\code_protect
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\project.sct
  group pac55xx_sdk
    ../pac55xx_sdk/boot_keil/: startup_pac55xx_keil.s system_pac5xxx.c system_pac5xxx.h
    ../pac55xx_sdk/driver/: pac5xxx_driver_adc.c pac5xxx_driver_adc.h pac5xxx_driver_config.h pac5xxx_driver_gpio.c pac5xxx_driver_gpio.h pac5xxx_driver_memory.h pac5xxx_driver_socbridge.c pac5xxx_driver_socbridge.h pac5xxx_driver_system.c pac5xxx_driver_system.h pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_timer.c pac5xxx_driver_timer.h pac5xxx_driver_uart.c pac5xxx_driver_uart.h pac5xxx_driver_can.c pac5xxx_driver_can.h
    ../pac55xx_sdk/peripheral/: pac5xxx.h pac5xxx_adc.h pac5xxx_can.h pac5xxx_crc.h pac5xxx_gp_timers.h pac5xxx_gpio.h pac5xxx_i2c.h pac5xxx_memory.h pac5xxx_rtc.h pac5xxx_scc.h pac5xxx_ssp.h pac5xxx_tile_driver_manager.h pac5xxx_tile_power_manager.h pac5xxx_tile_signal_manager.h pac5xxx_tile_system_manager.h pac5xxx_timers.h pac5xxx_uart.h pac5xxx_wwdt.h
    ../pac55xx_sdk/: pac5xxx_sdk_version.h
    ../pac55xx_sdk/device/: pac5523.h pac5532.h pac5556.h pac5524.h pac5527.h
  group adc_aio
    ../src/adc_aio/: adc_isr.c adc_app.c adc_func.c aio_app.c aio_func.c
  group can
    ../src/can/: can_isr.c can_app.c can_func.c
  group crc
    ../src/crc/: crc_app.c crc_func.c
  group flash
    ../src/flash/: flash_app.c flash_func.h flash_func.c
  group gpio
    ../src/gpio/: gpio_isr.c gpio_app.c gpio_func.c
  group gptimera
    ../src/gptimera/: gptimera_isr.c gptimera_app.c gptimera_func.c
  group gptimerb
    ../src/gptimerb/: gptimerb_isr.c gptimerb_app.c gptimerb_func.c
  group hibernate
    ../src/hibernate/: hib_app.c hib_func.c
  group i2c
    ../src/i2c/: i2c_app.c i2c_func.h i2c_isr.c i2c_func.c
  group power
    ../src/power/: power_app.c power_func.c
  group rtc
    ../src/rtc/: rtc_isr.c rtc_app.c rtc_func.c
  group ssp
    ../src/ssp/: ssp_app.c ssp_func.h ssp_isr.c ssp_func.c
  group sysclk
    ../src/sysclk/: sysclk_app.c sysclk_func.c
  group timer
    ../src/timer/: timer_isr.c capture_func.c pwm_driver_func.c pwm_func.c qep_func.c qep_isr.c timer_app.c timer_func.c
  group uart
    ../src/uart/: uart_isr.c uart_app.c uart_func.h uart_func.c
  group user
    ../src/user/: user.c user.h user_printf.c
  group wwdt
    ../src/wwdt/: wwdt_isr.c wwdt_app.c wwdt_func.c
  group src
    ../src/: app.h config.h main.c peripheral_variables.h
    ../: project_version.h
  group sleep
    ../src/sleep/: sleep.h sleep_app.c sleep_ramfunc.c
  group code_protect
    ../src/code_protect/: code_protect_app.c code_protect_func.c code_protect_func.h swd_unlock.S
    ./: preproc_swd_unlock.S
software components: CMSIS:CORE 4.1.0
