# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PAC5523 PAC5523
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\src; ..\pac55xx_sdk; ..\pac55xx_sdk\device; ..\pac55xx_sdk\boot_IAR; ..\pac55xx_sdk\driver; ..\pac55xx_sdk\peripheral; ..\src\gpio; ..\src\gptimera; ..\src\gptimerb; ..\src\rtc; ..\src\sysclk; ..\src\timer; ..\src\uart; ..\src\wwdt; ..\src\adc_aio; ..\src\can; ..\src\crc; ..\src\hibernate; ..\src\power; ..\src\user; ..\src\flash; ..\src\i2c; ..\src\ssp; ..\src\sleep; ..\src\code_protect
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  prebuild: cmd.exe /k "IF EXIST ""..\..\build_date_time.bat""  (""..\..\build_date_time.bat"" "$PROJ_DIR$"  iar) ELSE (exit)"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: pac55xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: c.out
  group (top)
    ../: project_version.h
  group pac55xx_sdk
    ../pac55xx_sdk/: pac5xxx_sdk_version.h
  group pac55xx_sdk/boot_IAR
    ../pac55xx_sdk/boot_IAR/: startup_pac55xx_iar.s
  group pac55xx_sdk/device
    ../pac55xx_sdk/device/: pac5523.h pac5524.h pac5527.h pac5532.h pac5556.h
  group pac55xx_sdk/driver
    ../pac55xx_sdk/driver/: pac5xxx_driver_adc.c pac5xxx_driver_adc.h pac5xxx_driver_can.c pac5xxx_driver_can.h pac5xxx_driver_config.h pac5xxx_driver_gpio.c pac5xxx_driver_gpio.h pac5xxx_driver_memory.h pac5xxx_driver_socbridge.c pac5xxx_driver_socbridge.h pac5xxx_driver_system.c pac5xxx_driver_system.h pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_timer.c pac5xxx_driver_timer.h pac5xxx_driver_uart.c pac5xxx_driver_uart.h
  group pac55xx_sdk/peripheral
    ../pac55xx_sdk/peripheral/: pac5xxx.h pac5xxx_adc.h pac5xxx_can.h pac5xxx_crc.h pac5xxx_gp_timers.h pac5xxx_gpio.h pac5xxx_i2c.h pac5xxx_memory.h pac5xxx_rtc.h pac5xxx_scc.h pac5xxx_ssp.h pac5xxx_tile_driver_manager.h pac5xxx_tile_power_manager.h pac5xxx_tile_signal_manager.h pac5xxx_tile_system_manager.h pac5xxx_timers.h pac5xxx_uart.h pac5xxx_wwdt.h
  group src
    ../src/: app.h config.h main.c peripheral_variables.h
  group src/adc_aio
    ../src/adc_aio/: adc_aio_func.h adc_app.c adc_func.c adc_isr.c aio_app.c aio_func.c
  group src/can
    ../src/can/: can_app.c can_func.c can_func.h can_isr.c
  group src/code_protect
    ../src/code_protect/: code_protect_app.c code_protect_func.c code_protect_func.h swd_unlock.S
  group src/crc
    ../src/crc/: crc_app.c crc_func.c crc_func.h
  group src/flash
    ../src/flash/: flash_app.c flash_func.c flash_func.h
  group src/gpio
    ../src/gpio/: gpio_app.c gpio_func.c gpio_func.h gpio_isr.c
  group src/gptimera
    ../src/gptimera/: gptimera_app.c gptimera_func.c gptimera_func.h gptimera_isr.c
  group src/gptimerb
    ../src/gptimerb/: gptimerb_app.c gptimerb_func.c gptimerb_func.h gptimerb_isr.c
  group src/hibernate
    ../src/hibernate/: hib_app.c hib_func.c hib_func.h
  group src/i2c
    ../src/i2c/: i2c_app.c i2c_func.c i2c_func.h i2c_isr.c
  group src/power
    ../src/power/: power_app.c power_func.c power_func.h
  group src/rtc
    ../src/rtc/: rtc_app.c rtc_func.c rtc_func.h rtc_isr.c
  group src/sleep
    ../src/sleep/: sleep.h sleep_app.c sleep_ramfunc.c
  group src/ssp
    ../src/ssp/: ssp_app.c ssp_func.c ssp_func.h ssp_isr.c
  group src/sysclk
    ../src/sysclk/: sysclk_app.c sysclk_func.c sysclk_func.h
  group src/timer
    ../src/timer/: capture_func.c pwm_driver_func.c pwm_func.c qep_func.c qep_isr.c Readme.txt timer_app.c timer_func.c timer_func.h timer_isr.c
  group src/uart
    ../src/uart/: uart_app.c uart_func.c uart_func.h uart_isr.c
  group src/user
    ../src/user/: user.c user.h user_printf.c
  group src/wwdt
    ../src/wwdt/: wwdt_app.c wwdt_func.c wwdt_func.h wwdt_isr.c
